# Keil uVision project Blinky.uvprojx, settings and files
target STM32F407 RAM (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000, VECT_TAB_SRAM
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x20010000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./Sources/: main.c supporting_functions.c accelerometer.c filter.c keypad.c LED.c segment_display.c tim.c accelerometer.h filter.h keypad.h LED.h segment_display.h tim.h clock.h clock.c gpio.c gpio.h
  group Accelerometer
    ./Accelerometer/src/: LIS3DSH.c
target Lab4 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 uC99=1
  c define: USE_HAL_DRIVER, STM32F407xx ,  __FPU_PRESENT=1 , HSE_VALUE=8000000
  c include: .\Headers;.\Accelerometer\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
target STM32F407 OPT (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 5.0.2, CMSIS:DSP 1.5.2, CMSIS:RTOS:Keil RTX 4.81.1, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube Framework:Classic 1.6.0, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:ADC 1.6.0, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:SPI 1.4.2, Device:STM32Cube HAL:SPI 1.6.0, Device:STM32Cube HAL:TIM 1.4.2, Device:STM32Cube HAL:TIM 1.6.0, Device:STM32Cube HAL:UART 1.4.2, Device:STM32Cube HAL:UART 1.6.0, Device:STM32Cube HAL:USART 1.4.2, Device:STM32Cube HAL:USART 1.6.0, Device:Startup 2.4.2, Device:Startup 2.6.0
